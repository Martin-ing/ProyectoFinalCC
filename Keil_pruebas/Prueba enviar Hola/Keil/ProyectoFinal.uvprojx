# Keil uVision project ProyectoFinal.uvprojx, settings and files
target K8 (6240000::V6.24::ARMCLANG)
  device: STM32F303K8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00003000) IRAM2(0x10000000,0x00001000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: ProyectoFinal
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  group Source
    ./: main.c phy_tx.c phy_tx.h chat_com.c chat_com.h phy_rx.c phy_rx.h
  group ComandosVerdes
    ./: Verdes.h sound.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.11.3
